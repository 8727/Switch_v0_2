# Keil uVision project switch_v0_2.uvprojx, settings and files
target SW_v0_2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: switch_v0_2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: Z:\Switch_v0_2;.\CMSIS\inc;..\SOURCE\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32f10x.c
  group StartUp
    ./CMSIS/StartUp/: startup_stm32f10x_hd.s
  group Source
    ../SOURCE/src/: main.c setting.c Ee24cxx.c rtc.c ili9488.c xpt2046.c dht22.c ds18b20.c w25qxx.c rs485.c can.c
